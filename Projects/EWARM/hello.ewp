# IAR project hello.ewp, settings and files
configuration hello Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32F439VI ST STM32F439VI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F439xx
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\Drivers\CMSIS\Include; ..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: hello Configuration.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group 
    ./: 
  group Application
    ./: 
  group Application/EWARM
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f439xx.s startup_stm32f439xx.s
  group Application/User
    ../../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Application/
    ./: 
  group Application/
    ./: 
  group Drivers
    ./: 
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c
  group Drivers/
    ./: 
  group Drivers/
    ./: 
